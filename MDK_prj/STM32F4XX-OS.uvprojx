# Keil uVision project STM32F4XX-OS.uvprojx, settings and files
target STM32F4XX-OS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4XX-OS +hex
  AfterMake: fromelf.exe --bin -o ./STM32F4XX-OS.bin  ./Objects/STM32F4XX-OS.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_STM324xG_EVAL,__FPU_PRESENT=1
  c include: ..\Source\User;..\Source\OS;..\Source\ST_Libraries\
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Source/ST_Libraries/Startup/: startup_stm32f4xx.s
  group CMSIS
    ../Source/ST_Libraries/CMSIS/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../Source/ST_Libraries/STM32F4XX_StdPeriph_Driver/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c misc.c
  group OS
    ../Source/OS/: OS.c OS.h OS_Conf.h OS_CLASS.h
  group User
    ../Source/User/: main.c
    ../Source/ST_Libraries/: stm32f4xx_it.c
  group User\serial_debug
    ../Source/User/serial_debug/: serial_debug.c
